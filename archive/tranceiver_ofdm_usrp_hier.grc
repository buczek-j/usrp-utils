options:
  parameters:
    author: root
    generate_options: qt_gui
    id: transreceiver_ofdm_usrp_hier
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: packet_len
  id: variable
  parameters:
    value: '256'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '255'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.05'
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: packet_length_tag_key
    packet_len: packet_len
    type: byte
  states: {}
- name: rx_bw
  id: parameter
  parameters:
    label: rx_bw
    value: 0.5e6
  states: {}
- name: rx_freq
  id: parameter
  parameters:
    label: rx_freq
    value: 2e9
  states: {}
- name: rx_gain
  id: parameter
  parameters:
    label: rx_gain
    value: '0.8'
  states: {}
- name: rx_ofdm_0
  id: rx_ofdm
  parameters: {}
  states: {}
- name: tx_bw
  id: parameter
  parameters:
    label: tx_bw
    value: 0.5e6
  states: {}
- name: tx_freq
  id: parameter
  parameters:
    label: tx_freq
    value: 2.0e9
  states: {}
- name: tx_gain
  id: parameter
  parameters:
    label: tx_gain
    value: '1'
  states: {}
- name: tx_ofdm_msg_0
  id: tx_ofdm_msg
  parameters: {}
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: tx_freq
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: packet_length_tag_key
    norm_gain0: 'False'
    samp_rate: tx_bw
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: rx_freq
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: rx_gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: rx_bw
    sync: pc_clock
    type: fc32
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://*:55555
    timeout: '100'
    type: byte
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: '"tcp://127.0.0.1:"+input_port_num'
    timeout: '100'
    type: byte
  states: {state: disabled}

connections:
- [analog_random_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', tx_ofdm_msg_0, '0']
- [rx_ofdm_0, '0', zeromq_pub_sink_0, '0']
- [tx_ofdm_msg_0, '0', blocks_multiply_const_vxx_0, '0']
- [uhd_usrp_source_0, '0', rx_ofdm_0, '0']
- [zeromq_sub_source_0, '0', blocks_stream_to_tagged_stream_0, '0']

metadata:
  file_format: 1
