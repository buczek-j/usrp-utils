options:
  parameters:
    author: root
    generate_options: no_gui
    id: testing_encoder3_RS
    output_language: python
    run_options: run
    title: testing_encoder3_RS
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {state: disabled}
- name: blocks_ctrlport_monitor_performance_0
  id: blocks_ctrlport_monitor_performance
  parameters:
    en: 'True'
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /root/repos/usrp-utils/archive/post_decoder.bin
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: /root/repos/usrp-utils/archive/post_encoder.bin
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: /root/repos/usrp-utils/archive/pre_crc.bin
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: /root/repos/usrp-utils/archive/post_crc.bin
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0_1
  id: blocks_file_sink
  parameters:
    file: /root/repos/usrp-utils/archive/post_crc_check.bin
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: pkt_len
    packet_len: frame_size
    type: byte
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: n
    type: byte
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: frame_size+4
    type: byte
  states: {}
- name: blocks_vector_source_x_0_1_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: byte
    vector: (frame_size//10)*[0,1,2,4,8,16,32,64,128,255]
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: n
    type: byte
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: int(frame_size+4)
    type: byte
  states: {}
- name: digital_crc32_bb_0_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: pkt_len
    packed: 'True'
  states: {}
- name: digital_crc32_bb_0_0_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: pkt_len
    packed: 'True'
  states: {}
- name: dtv_dvbt_reed_solomon_dec_0
  id: dtv_dvbt_reed_solomon_dec
  parameters:
    blocks: '1'
    gfpoly: '0x11d'
    k: int(frame_size+4)
    m: '8'
    n: n
    p: '2'
    s: '0'
    t: int((n-int(frame_size+4))/2)
  states: {}
- name: dtv_dvbt_reed_solomon_enc_0
  id: dtv_dvbt_reed_solomon_enc
  parameters:
    blocks: '1'
    gfpoly: '0x11d'
    k: int(frame_size+4)
    m: '8'
    n: n
    p: '2'
    s: '0'
    t: int((n-int(frame_size+4))/2)
  states: {}
- name: dtv_dvbt_reed_solomon_enc_1
  id: dtv_dvbt_reed_solomon_enc
  parameters:
    blocks: '8'
    gfpoly: '0x11d'
    k: '239'
    m: '8'
    n: '255'
    p: '2'
    s: '51'
    t: '8'
  states: {state: disabled}
- name: frame_size
  id: parameter
  parameters:
    label: Frame Size
    type: intx
    value: '200'
  states: {}
- name: k
  id: parameter
  parameters:
    label: k
    type: intx
    value: int(frame_size+4)
  states: {state: disabled}
- name: n
  id: parameter
  parameters:
    label: n
    type: intx
    value: '300'
  states: {}

connections:
- [blocks_stream_to_tagged_stream_0_0, '0', blocks_file_sink_0_0_0_0_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', digital_crc32_bb_0_0, '0']
- [blocks_stream_to_vector_0, '0', dtv_dvbt_reed_solomon_dec_0, '0']
- [blocks_stream_to_vector_1, '0', dtv_dvbt_reed_solomon_enc_0, '0']
- [blocks_vector_source_x_0_1_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_file_sink_0_0_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_vector_to_stream_0_0, '0', digital_crc32_bb_0_0_0, '0']
- [digital_crc32_bb_0_0, '0', blocks_file_sink_0_0_0_0_0_0, '0']
- [digital_crc32_bb_0_0, '0', blocks_stream_to_vector_1, '0']
- [digital_crc32_bb_0_0_0, '0', blocks_file_sink_0_0_1, '0']
- [dtv_dvbt_reed_solomon_dec_0, '0', blocks_vector_to_stream_0_0, '0']
- [dtv_dvbt_reed_solomon_enc_0, '0', blocks_vector_to_stream_0, '0']

metadata:
  file_format: 1
